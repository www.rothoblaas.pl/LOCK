Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: a74b4db4-762e-4688-84c5-4cdd7b1306c6, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Structural]
File name: Project Number
Time: 2024-07-18T13:24:40+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENG) - IFC 24.2.10.64

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Level Head - FFL (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level Head - FFL; Type: Level Head - FFL; Type Id: 146979
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - FFL; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level Head - FFL
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 3000

# IfcDiscreteAccessory: ROTHOB_Rothoblaas_Plate_LockStop_P5U-P125_35:LOCKSTOP35_041x28.5x13mm, ROTHOB_Rothoblaas_Plate_LockStop_P5U-P125_35:LOCKSTOP35_041x28.5x13mm:433685
In: Level 2
Type - Material: <Unnamed>
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; CECode: ETA-19/0831; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Concealed hook timber-to-concrete connector; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_LockStop_P5U-P125_35; Features: Locking device for lateral forces; Finish: n/a; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Stainless steel; MinWeight: 0.033 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: LOCKSTOP35; ModelReference: n/a; Name: Plate; NominalDepth: 13 mm; NominalHeight: 28.5 mm; NominalLength: n/a; NominalWidth: 41 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 41x28.5x13 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 35
Type - Dimensions - Depth_P: 13 mm; Height_H: 28.5 mm; Thickness_s: 2.5 mm; Width_B: 41 mm
Type - General - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_LockStop_P5U-P125; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/concealed-connections/lock-c; Revision: 1; UniClass2015Code: Pr_20_85_09_81; UniClass2015Title: Stainless steel brackets; UniClass2015Version: Products v1.33; Version: 2
Type - Identity Data - OmniClass Number: 23.13.23.11.19.13; Type Name: LOCKSTOP35_041x28.5x13mm
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteel
Type - Visibility - HasHole_LOCKSTOP35: yes
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate
Pset_QuantityTakeOff - Reference: LOCKSTOP35_041x28.5x13mm
Other - Family: ROTHOB_Rothoblaas_Plate_LockStop_P5U-P125_35; Family and Type: ROTHOB_Rothoblaas_Plate_LockStop_P5U-P125_35: LOCKSTOP35_041x28.5x13mm; Type: LOCKSTOP35_041x28.5x13mm; Type Id: 514967
Constraints - Elevation from Level: -3000 mm; Host: <not associated>; Level: Level 2; Schedule Level: Level 2
Dimensions - Volume: 0.00000394718 m3
Phasing - Phase Created: New Construction

# IfcOpeningElement: Opening (4)
In: Level 2
Pset_OpeningElementCommon - Reference: LOCKSTOP35_041x28.5x13mm; sets with these values: 2
Name (ROTHOB_Rothoblaas_Plate_LockStop_P5U-P125_35:LOCKSTOP35_041x28.5x13mm:433685:...)
1
2
3
4
