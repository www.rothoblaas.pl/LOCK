Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: a74b4db4-762e-4688-84c5-4cdd7b1306c6, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Structural]
File name: Project Number
Time: 2024-07-18T09:37:16+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENG) - IFC 24.2.10.64

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Level Head - FFL (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level Head - FFL; Type: Level Head - FFL; Type Id: 146979
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - FFL; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level Head - FFL
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 3000

# IfcMember: ROTHOB_Rothoblaas_Plate_LockT_MiniEvo_1880:LOCKTEVO1880_17.50x80x20mm, ROTHOB_Rothoblaas_Plate_LockT_MiniEvo_1880:LOCKTEVO1880_17.50x80x20mm:433685
In: Level 2
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_Aluminium_EvoCoating
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; CECode: ETA-19/0831; CETitle: n/a; CodePerformance: CE - Construction products; Color: Grey; Constituents: n/a; Description: Concealed timber-to-timber connector; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_LockT_MiniEvo_1880; Features: Bracket for timber-to-timber, timber-to-concrete, timber-to-steel joints; Finish: EVO coating; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Aluminium; MinWeight: 0.045 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: LOCKTEVO1880; ModelReference: n/a; Name: Plate; NominalDepth: 20 mm; NominalHeight: 80 mm; NominalLength: n/a; NominalWidth: 17.5 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 17.50x80x20 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 1880
Type - Dimensions - Depth_P: 20 mm; Height_H: 80 mm; HoleQuantity_nscrews_Ø5: 4; Width_B: 17.5 mm
Type - General - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_LockT_MiniEvo; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/concealed-connections/lock-t-mini; Revision: 1; UniClass2015Code: Pr_20_76_51_07; UniClass2015Title: Aluminium structural sections; UniClass2015Version: Products v1.33; Version: 2
Type - Identity Data - OmniClass Number: 23.13.23.11.19.13; Type Name: LOCKTEVO1880_17.50x80x20mm
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_Aluminium_EvoCoating
Type - Visibility - HasHole_LOCKTEVO1880: yes; HasHole_LOCKTEVO35100: no; HasHole_LOCKTEVO35120: no; HasHole_LOCKTEVO3580: no; HasHole_LOCKTEVO53120: no
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate
Pset_MemberCommon - Reference: LOCKTEVO1880_17.50x80x20mm
Pset_QuantityTakeOff - Reference: LOCKTEVO1880_17.50x80x20mm
Other - Family: ROTHOB_Rothoblaas_Plate_LockT_MiniEvo_1880; Family and Type: ROTHOB_Rothoblaas_Plate_LockT_MiniEvo_1880: LOCKTEVO1880_17.50x80x20mm; Type: LOCKTEVO1880_17.50x80x20mm; Type Id: 433606
Constraints - Elevation from Level: -3000 mm; Host: <not associated>; Level: Level 2; Schedule Level: Level 2
Dimensions - Volume: 0.00000806275 m3
Phasing - Phase Created: New Construction
Structural - Rebar Cover: XD1\XC3/4 (C32/40,0.55,320) <30 mm>

# IfcOpeningElement: Opening (2)
In: Level 2
Pset_OpeningElementCommon - Reference: LOCKTEVO1880_17.50x80x20mm; sets with these values: 2
Name (ROTHOB_Rothoblaas_Plate_LockT_MiniEvo_1880:LOCKTEVO1880_17.50x80x20mm:433685:...)
1
2
